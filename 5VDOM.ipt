# Autodesk Inventor part: 5VDOM
## iProperties
Created: 2008-10
Part Number: 5VDOM
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
